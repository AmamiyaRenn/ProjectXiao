# Keil uVision project ProjectXiao.uvprojx, settings and files
target XiaoIsTheCutestGirl (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Xiao +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Master\INC;.\Body\INC;.\Control\INC;.\Function\INC;.\Hardware\INC;.\System\INC;.\Libraries\STM32F10x_FWLib\inc;.\Libraries\CORE;.\UCOSII\CORE;.\UCOSII\PORT;.\UCOSII\CONFIG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Master
    ./Master/SRC/: main.cpp Xiao.cpp IRQHandler.cpp MasterParam.cpp IRCtrl.cpp
  group Control
    ./Control/INC/: RunControl.h
  group Body
    ./Body/SRC/: Chassis.cpp
  group Function
    ./Function/INC/: MyMath.h queue.h Coordinate.h pid.h data_processing.h
  group Hardware
    ./Hardware/INC/: Macro.h
    ./Hardware/SRC/: usart.cpp dma.cpp led.c timer.cpp Beep.c
  group README
    ./: README.md
  group System
    ./System/SRC/: delay.c sys.c stm32f10x_it.c system_stm32f10x.c
  group LIB
    ./Libraries/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ./Libraries/CORE/: startup_stm32f10x_hd.s
  group UCOSII_CORE
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group UCOSII_PORT
    ./UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII_CONFIG
    ./UCOSII/CONFIG/: includes.h os_cfg.h
software components: CMSIS:CORE 5.6.0
